# Keil uVision project STM32-OffineSWD.uvprojx, settings and files
target STM32-OfflineSWD (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32-OffineSWD +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,BLUEPILL,SWO_PB7,SWD_REMAP
  c include: ..\USER;..\CORE;..\HARDWARE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\SYSTEM\spi;..\HARDWARE\W25Qxx;..\HARDWARE\ff9\src;..\HARDWARE\Mass_Storage\inc;..\HARDWARE\STM32_USB-FS-Device_Driver\inc;..\HARDWARE\Offline_SWD;..\HARDWARE\DAP;..\HARDWARE\SWD;..\HARDWARE\algo;..\HARDWARE\OLED;..\HARDWARE\another;..\HARDWARE\DAP_USB\inc;..\HARDWARE\DAP_UART;..\CMSIS\CoreSupport;..\CMSIS\5.6.0\CMSIS\Include;..\CMSIS\5.6.0\CMSIS\Driver\Include;..\RL\USB\INC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../USER/: main.c CMSIS-DAP.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/SPI/: spi.c
  group CORE
    ../CORE/: startup_stm32f10x_hd.s system_stm32f10x.c
    ../CMSIS/CoreSupport/: core_cm3.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_fsmc.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_tim.c
  group HARDWARE
    ../HARDWARE/another/: led.c key.c hex2bin.c
  group FF
    ../HARDWARE/ff9/src/: diskio.c ff.c
    ../HARDWARE/ff9/src/option/: ccsbcs.c syscall.c
  group MASS_STORAGE
    ../HARDWARE/Mass_Storage/src/: fsmc_nand.c hw_config.c mass_mal.c memory.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group USB_DRIVE
    ../HARDWARE/STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group DAP
    ../HARDWARE/DAP/: DAP.c SW_DP.c DAP_vendor.c JTAG_DP.c SWO.c
  group DAP_USB
    ../HARDWARE/DAP_USB/src/: usb_config.c usbd_STM32F103.c usbd_user_hid.c usbd_user_cdc_acm.c
    ../HARDWARE/DAP_USB/: USB_CM3.lib
  group DAP_UART
    ../HARDWARE/DAP_UART/: DMA_STM32F10x.c GPIO_STM32F10x.c USART_STM32F10x.c
  group SWD
    ../HARDWARE/SWD/: SWD_flash.c SWD_host.c SWD_opt.c
  group FLASH
    ../HARDWARE/algo/: STM32F10x_128.c STM32F10x_OPT.c
  group OLED
    ../HARDWARE/OLED/: oled.c
  group W25QXX
    ../HARDWARE/W25QXX/: w25qxx.c
